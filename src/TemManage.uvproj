# Keil uVision project TemManage.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: TemManage +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: TemManage.h TemManage.c lcd1602.c lcd1602.h ds18b20.c ds18b20.h delay.c delay.h
